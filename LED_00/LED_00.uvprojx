# Keil uVision project LED_00.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED_00 +hex
  c flags: Optim=2 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: main.c startup_stm32f10x_hd.s stm32f10x.h
